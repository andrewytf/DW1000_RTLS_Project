# Keil uVision project DWM_project.uvprojx, settings and files
target DWM_project (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.1.0.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: DWM_project
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L476xx
  c misc: --C99
  c include: ../Inc;        ../Drivers/STM32L4xx_HAL_Driver/Inc;        ../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;        ../Drivers/CMSIS/Include;        ../Drivers/CMSIS/Device/ST/STM32L4xx/Include;        ..\decadriver;        ..\RL_drivers
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --diag_suppress=L6329
  group Application/User
    ../Src/: stm32l4xx_it.c stm32l4xx_hal_msp.c main.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32L4xx/Source/Templates/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_i2c.c stm32l4xx_hal_gpio.c stm32l4xx_hal.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_dma.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rtc.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_pwr.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_pcd_ex.c stm32l4xx_ll_usb.c stm32l4xx_hal_pcd.c
  group Application/MDK-ARM
    ./: startup_stm32l476xx.s
  group decadriver
    ../decadriver/: deca_device.c deca_params_init.c
  group RL_drivers
    ../RL_drivers/: deca_spi.c deca_com.c usart_com.c
software components: CMSIS:CORE 4.1.0
